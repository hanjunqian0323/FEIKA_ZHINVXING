# Keil uVision project k66_sdk.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK66FX1M0xxx18 NXP
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x1FFF0000,0x00010000) IROM(0x00000000,0x00100000) IROM2(0x10000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: k66_sdk
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG,CPU_MK66FX1M0VLQ18, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0, FRDM_K66F, FREEDOM
  c misc: --library_interface=armcc --diag_suppress=1296,186
  c include: ..\board;..\components\lists;..\components\serial_manager;..\components\uart;..\drivers\arm;..\drivers\cmsis_drivers;..\drivers\drivers;..\source;..\startup;..\utilities\str;..\utilities\str;..\utilities\debug_console;..\drivers\CMSIS\Include;..\source\LED;..\source\KEY;..\source\PIT;..\source\PWM;..\source\DELAY;..\source\INCAP;..\source\ADC;..\source\OV7725;..\source\SCCB;..\source\DMA;..\source\COMPUTER;..\source\UART
  asm define: CPU_MK66FX1M0VLQ18, DEBUG,__CC_ARM,KEIL,FRDM_K66F180M, FREEDOM, DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ..\drivers\arm\MK66FX1M0xxx18_flash.scf
  link misc: --remove
  group source
    ../source/: main.c
    ../source/KEY/: KEY.c
    ../source/LED/: LED.c
    ../source/PIT/: PIT.c
    ../source/PWM/: PWM.c
    ../source/DELAY/: DELAY.c
    ../source/INCAP/: INCAP.c
    ../source/ADC/: K66ADC.c
    ../source/OV7725/: OV7725.c
    ../source/SCCB/: SCCB.c
    ../source/DMA/: DMA.c
    ../source/COMPUTER/: computer.c
    ../source/UART/: UsART.c
  group board
    ../board/: board.c clock_config.c pin_mux.c
  group driver
    ../drivers/drivers/: fsl_gpio.c fsl_clock.c fsl_ftfx_cache.c fsl_ftfx_controller.c fsl_ftfx_flash.c fsl_ftfx_flexnvm.c fsl_common.c fsl_uart.c fsl_lpuart.c fsl_smc.c fsl_ftm.c fsl_pit.c fsl_dmamux.c fsl_edma.c
  group device
    ../startup/: system_MK66F18.c
  group utilities
    ../utilities/debug_console/: fsl_debug_console.c
    ../utilities/str/: fsl_str.c
    ../utilities/: fsl_assert.c
  group component-uart
    ../components/uart/: uart_adapter.c
  group component-serial_manager
    ../components/serial_manager/: serial_manager.c serial_port_uart.c
  group component-lists
    ../components/lists/: generic_list.c
  group startup
    ../drivers/arm/: startup_MK66F18.s
